# Keil uVision project calendar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: calendar +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFiles
    ../source/: main.c LCD1602.c DS1302.c DS18B20.c Key_Buzzer.c lunar.c app.c
  group IncludeFiles
    ../source/: main.h config.h LCD1602.h DS1302.h DS18B20.h Key_Buzzer.h lunar.h app.h
