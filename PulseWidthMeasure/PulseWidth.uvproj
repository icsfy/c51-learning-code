# Keil uVision project PulseWidth.uvproj, settings and files
target PulseWidth (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: PulseWidth +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./source/: main.c uart.c
