# Keil uVision project DripSpeed.uvproj, settings and files
target DripSpeed (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: DripSpeed +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./source/: main.c digital_display.c uart.c esp8266.c
